options:
  parameters:
    generate_options: qt_gui
    id: Digmod_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: baseband_LO
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707, -0.707]'
    imag_sect: '0'
    real_sect: '2'
    rot_sym: '1'
    sym_map: '[0, 1]'
    w_imag_sect: '0'
    w_real_sect: '1'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(3e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rnd-elec-sdr-02rva/Documents/uauaua
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/rnd-elec-sdr-02rva/file_sink.txt
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/rnd-elec-sdr-02rva/Desktop/test_dig.wav
    samp_rate: '44100'
  states: {state: disabled}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0648'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '3000000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: 192.168.2.1
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 2400e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 0.1e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    label1: Locked
    name: '"received + poly + costas"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    gui_hint: 1,1,1,1
    label1: Locked
    name: '"received + poly"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    label1: Locked
    name: '"received"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    label1: Locked
    name: '"received + poly + costas + eq"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '8'
    taps: ''
    type: ccc
  states: {state: bypassed}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_probe_rate_0, '0']
- [blocks_pack_k_bits_bb_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_2, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_1, '0']
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', audio_sink_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', blocks_file_sink_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', blocks_probe_rate_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
